# Keil uVision project stm32.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32 +hex
  c flags: Optim=1 wLevel=2
  c include: ..\library\cmsis;..\library\fwlib\inc;..\user;..\user\api;..\GUI;..\GUI\GUI_TEST;..\GUI\ZLG_GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group cmsis
    ../library/cmsis/: core_cm3.c core_cm3.h
  group fwlib
    ../library/fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.h
  group bsp
    ../user/api/: led.c beep.c key.c usart.c exti0.c systick.c exti0.h key.h led.h systick.h usart.h lcd.c zi.c zi.h lcd2.c IIC.c DHT11.c DHT11.h time6.c touch.c flash.c flash.h lcd.h time4.c time3.c adc.c 485.c 485.h
  group GUI
    ../GUI/: lcddrive.c
    ../GUI/ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C loadbit.c menu.c spline.c windows.c
    ../GUI/GUI_TEST/: gui_test.c
